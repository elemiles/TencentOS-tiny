# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\TOS\arch\arm-v7m\common\include;..\TOS\arch\arm-v7m\cortex-m3\armcc;..\TOS\core\core\include;..\TOS\core\pm\include;..\TOS\tosconfig
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../OBJ/: startup_stm32f10x_md.s
    ../SYSTEM/: system_stm32f10x.c
  group USER
    ./: test.c
    ../SYSTEM/: stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group README
    ../: README.TXT
  group tos/kernel
    ../TOS/core/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../TOS/core/pm/: tos_pm.c tos_tickless.c
  group tos/arch
    ../TOS/arch/arm-v7m/common/: tos_cpu.c tos_fault.c
    ../TOS/arch/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
  group tos/config
    ../TOS/tosconfig/: tos_config.h
